# Keil uVision project ModularReader.uvprojx, settings and files
target ModularReader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ModularReader +hex
  AfterMake: fromelf --bin -o ".\bin_file\@L.bin" "#L"
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,__FPU_PRESENT=1,__FPU_USED =1,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --c99
  c include: .\Libraries\CMSIS\Include;.\Libraries\CMSIS\ST\STM32F4xx\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\FreeRTOS\portable\MemMang;.\Applications;.\Driver;.\BSP;.\Math;.\Utility;.\Libraries\USB\STM32_USB_APP\USB_Device_Examples\VCP;.\Libraries\USB\STM32_USB_Device_Library\Core;.\Libraries\USB\STM32_USB_Device_Library\Class\cdc;.\Libraries\USB\STM32_USB_OTG_Driver;.\Libraries\FATFS\src;.\GUI;.\Applications;.\ODRIVE_CAN;.\Applications\APP;.\Applications\STATE;.\Applications\BSP_eeprom;.\Applications\REMOTE
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./Applications/: app_Init.c control.c clockcount.c odrive.c main.c supervisor.c lcd.c pid.c balance.c XHC_Task.c CAN2_Task.c MYADC.c
    ./Applications/APP/: app.c
    ./Applications/STATE/: State.c
    ./Applications/BSP_eeprom/: BSP_eeprom.c
    ./Applications/REMOTE/: remote.c
  group driver
    ./Driver/: driver_clockCount.c driver_crc.c driver_rgb.c driver_usbvcp.c isp_exit.c isp_spi.c isp_tim.c ISP_USART.c driver_lcd.c driver_key.c
    ./BSP/: JY60.c
  group bsp
    ./BSP/: bsp_can.c bsp_exit.c bsp_gpio.c bsp_spi_hw.c bsp_timer.c bsp_pwm.c bsp_watchDog.c BSP_DMA.c BSP_USART.c bsp_iic.c usartx.c vofa.c cigan.c encoder.c
  group lib
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_dac.c stm32f4xx_flash.c stm32f4xx_i2c.c stm32f4xx_it.c stm32f4xx_wwdg.c stm32f4xx_iwdg.c stm32f4xx_sdio.c
    ./FreeRTOS/: list.c event_groups.c croutine.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./Libraries/USB/STM32_USB_OTG_Driver/: usb_core.c usb_dcd.c usb_dcd_int.c
    ./Libraries/USB/STM32_USB_Device_Library/Core/: usbd_core.c usbd_ioreq.c usbd_req.c
  group math
    ./Math/: algebra.c matrix.c ramp.c rotations.c srcdkf.c Ano_Math.c
  group util
    ./Utility/: cpu_utils.c util.c
  group CMSIS
    ./Libraries/CMSIS/Include/: arm_cortexM4lf_math.lib startup_stm32f40_41xxx.s
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group system_config
    ./Applications/: config.c
    ./Driver/: driver_flash.c
    ./BSP/: bsp_flash.c
  group LASER
    ./Driver/: driver_laser.c MODBUSProtocol.c
  group DOC
    ./DOC/: readme.txt
